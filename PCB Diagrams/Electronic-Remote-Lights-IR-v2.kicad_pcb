# Repository andres-garcia-alves/electronic-ir-remote-light

File README.md:

# IR Remote Lights

Electronic proyect to turn lights off/on using an Infrared (IR) remote control, plus sleep operation for low power consumption.  
Kicad PCB diagrams and Blender case 3D models are also provided ;-)  

Inspired by video [Sistema de Encendido de Luces Dual de 8 Canales, por Infrarrojo y Pulsadores](https://www.youtube.com/watch?v=uvJIHicDhEo) (spanish) from [CarlosVolt Electrónica & Robótica](https://www.youtube.com/@Carlosvolt) YouTube channel.

&nbsp;

This project use the following electronic components:
- 1 x Arduino Nano v3.0
- 1 x Infrared sensor VS1838B
- 1 x Relay SRD-05VDC-SL-C (5V)
- 3 x LED 5mm
- 2 x 4.7k ohm resistors
- 1 x 470k ohm resistor
- 1 x ON/OFF button
- 1 x Push-button

The circuit:
- After Arduino starts, external interruptions are enabled on it, and it is puted on sleep mode for low power consumption.
- The IR-sensor is powered directly to 5V (outside from the Arduino).
- When a remote control button is pressed the infrared code is detectec by the IR-sensor.
- The IR-sensor wakeup the Arduino board vía an external interruption (allowed pins 2 & 3).
- The source code uses IRremote v1.4 library to decode the received IR code, and if it is correct, switch on/off a relay.
- The relay is connected in series within the regular light powering wire.

Notes:
- IR Codes changes from remote control to remote control.
- You can look after your's remote control codes conecting the IR sensor to the Arduino board, and within the Arduino IDE using the serial monitor.
- The provided source code can do this for your, just make sure to change the DEBUG macro value to 'true'.

&nbsp;

### Screenshots

| Diagram - Schematics                               | Diagram - PCB                                      |
|----------------------------------------------------|----------------------------------------------------|
|             |                   |

| Diagram - PCB Render                               | Diagram - PCB Render                               |
|----------------------------------------------------|----------------------------------------------------|
|         |          |

| Case - 3D Model                                    | Prototype                                          |
|----------------------------------------------------|----------------------------------------------------|
|              |                     |

| PCB Manufacturing                                  | PCB Assembly                                       |
|----------------------------------------------------|----------------------------------------------------|
|             |                  |

| Project Assembly                                   | Diagram - Electric Connections                     |
|----------------------------------------------------|----------------------------------------------------|
|              |  |

| Project Final                                      | Project Final (YouTube video)                      |
|----------------------------------------------------|----------------------------------------------------|
|              |  |

See 'Rescources' sub-folder for more pictures & videos of the project.

&nbsp;

### Version History

v1.0 (2023.05.07) - Initial release.  
v1.1 (2023.05.08) - Adding use of sleep mode + interrupts to reduce power consumption.  
v1.2 (2023.05.11) - Rearrange assigned pins to improve PCB design.  
v1.3 (2023.05.20) - Rearrange assigned pins to improve PCB design.

&nbsp;

This source code is licensed under GPL v3.0  
Please send me your feedback about this project: andres.garcia.alves@gmail.com

## KiCad design PCB Diagrams/Electronic-Remote-Lights-IR-v2.kicad_pcb

Parts:
A1: Arduino Nano v3.x; Arduino_Nano
D1, D2, D3: LED; LED_D5.0mm
D4: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_2.1mm
J1: POWER; PinHeader_1x02_P2.54mm_Vertical
J2: 220V; TerminalBlock_bornier-2_P5.08mm
K1: RELAY; Relay_SPDT_SANYOU_SRD_Series_Form_C
Q1: BC547; TO-92_Inline_Wide
R1, R2: 4K7; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: RESET; SW_PUSH-12mm
U1: VS1838B; Vishay_MINICAST-3Pin

Connections:
+5V: A1.30 (VIN), J1.1, Q1.1 (C), R1.1, U1.3 (VSS)
GND: A1.4 (GND), D1.1 (K), D2.1 (K), D3.1 (K), D4.2 (A), J1.2, K1.5, SW1.2, U1.2 (GND)
LINE: J2.2, K1.1
NEUT: J2.1, K1.4
unnamed: A1.3 (~RESET), SW1.1
unnamed: A1.5 (D2), Q1.2 (B)
unnamed: A1.6 (D3), U1.1 (OUT)
unnamed: A1.15 (D12), R2.1
unnamed: A1.16 (D13), R3.1
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.1 (K), K1.2, Q1.3 (E)

Board: 2 copper layers, 62.1 x 62.2 mm, 18 parts (0 on the bottom side), 13 nets.

## KiCad design Electronic-Remote-Lights-IR.kicad_pcb

Parts:
A1: Arduino Nano v3.0; Arduino_Nano
D1, D2, D3: LED; LED_D5.0mm
H1, H2, H3, H4, H5: MountingHole; MountingHole_2.1mm
J1: POWER_PINS; PinHeader_1x02_P2.54mm_Horizontal
J2: POWER_USB; USB_A_Molex_67643_Horizontal
J3: RELAY; PinHeader_1x03_P2.54mm_Horizontal
R1, R2: 4K7; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: RESET; SW_PUSH-12mm
U1: VS1338B; Vishay_MINICAST-3Pin

Connections:
+5V: A1.30 (VIN), J1.2, J2.1 (VBUS), J3.3, R1.1, U1.3 (VSS)
GND: A1.4 (GND), D1.1 (K), D2.1 (K), D3.1 (K), J1.1, J2.4 (GND), J2.5 (Shield), J3.2, U1.2 (GND)
unnamed: A1.5 (D2), U1.1 (OUT)
unnamed: A1.16 (D13), R3.1
unnamed: A1.19 (A0), R2.1
unnamed: A1.26 (A7), J3.1
unnamed: A1.28 (~RESET), SW1.1
unnamed: A1.29 (GND), SW1.2
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2

Board: 2 copper layers, 62.7 x 69.2 mm, 17 parts (0 on the bottom side), 11 nets.

## Commit log

2023-05-09 Create LICENSE
2023-05-10 adding electronic diagrams
2023-05-11 pcb size optimizations
2023-05-11 adding schematics & pcb screenshots
2023-05-11 adding .gitignore
2023-05-11 rearrange assigned pins
2023-05-12 improved directory structure
2023-05-13 adding case 3D model
2023-05-17 adding electric connections diagram
2023-05-20 adding PCB desing v2.0
2023-05-21 adding case v2.0 3D model
2023-05-21 updating .gitignore
2023-05-24 PCB bug fix
2023-05-24 PCB component renamed
2023-05-26 adding PCB photos
2023-05-29 adding project completion photos
